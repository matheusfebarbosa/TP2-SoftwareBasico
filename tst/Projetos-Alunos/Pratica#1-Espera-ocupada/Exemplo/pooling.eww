<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Pratica#4-Conversor-AD\Exemplo\conversor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Pratica#4-Conversor-AD\Resoluзгo\Conversor a - d - Resoluзгo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Pratica#2-Interrupcao\Exemplo\interrupзao.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Pratica#2-Interrupcao\Resoluзгo\Interrupзгo - Resoluзгo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pooling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Resoluзгo\Pooling - resoluзгo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Pratica#3-Temporizador\Exemplo\timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Pratica#3-Temporizador\Resoluзгo\Timer - Resoluзгo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


